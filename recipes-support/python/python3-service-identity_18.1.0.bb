inherit setuptools3
require python-service-identity.inc
