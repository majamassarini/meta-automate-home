inherit setuptools3
require python-django-tagging.inc
