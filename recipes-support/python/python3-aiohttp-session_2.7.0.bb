inherit setuptools3
require python-aiohttp-session.inc

SRC_URI[sha256sum] = "18ae740845214086f783574edfee1bac36862332bd11d561e048b079d8f6ad34"
