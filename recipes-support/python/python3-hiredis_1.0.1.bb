inherit setuptools3
require python-hiredis.inc
