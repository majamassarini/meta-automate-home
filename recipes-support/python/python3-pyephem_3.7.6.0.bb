inherit setuptools3
require python-pyephem.inc


