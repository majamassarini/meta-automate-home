inherit setuptools3
require python-aioredis.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=88ef1c321d5b55543c45ca59683dcb90"
SRC_URI[md5sum] = "7577e902854a66649c34866e1d3197c0"
