inherit setuptools3
require python-aiohttp-security.inc

SRC_URI[sha256sum] = "40d4bb150454e392c2dfa3620f6eab28e140e94cf0c2d3b4bf43aef653ec9405"
