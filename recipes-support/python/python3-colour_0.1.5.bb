inherit setuptools3
require python-colour.inc
