include recipes-core/images/daemon-node.bb

IMAGE_FEATURES_append = "\
  dev-pkgs \
  debug-tweaks \
  "
