require recipes-core/images/brain-node.bb


IMAGE_FEATURES_append = "\
  dev-pkgs \
  debug-tweaks \
  "
