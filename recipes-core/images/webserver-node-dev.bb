include recipes-core/images/webserver-node.bb

IMAGE_FEATURES_append = "\
  dev-pkgs \
  debug-tweaks \
  "

