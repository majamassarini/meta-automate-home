RDEPENDS_${PN} = "${PYTHON_PN}-idna"
